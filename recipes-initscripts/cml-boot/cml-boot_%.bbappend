SRC_URI += "\
	file://29-rpi-init-tpm.fragment \
"
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
